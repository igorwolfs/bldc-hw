/*
 * Copyright (c) 2017 I-SENSE group of ICCS
 *
 * SPDX-License-Identifier: Apache-2.0
 */

/dts-v1/;
#include <st/f3/stm32f303Xc.dtsi>
#include <st/f3/stm32f303v(b-c)tx-pinctrl.dtsi>
#include <zephyr/dt-bindings/input/input-event-codes.h>

/ {
	model = "bldc";
	compatible = "st,stm32f3discovery";

	chosen {
		zephyr,console = &usart1;
		zephyr,shell-uart = &usart1;
		zephyr,sram = &sram0;
		zephyr,flash = &flash0;
		zephyr,canbus = &can1;
	};

	gpio_inputs {
		usb_sense: usb_sense {
			gpios = <&gpioa 10 GPIO_ACTIVE_HIGH>;
			label = "USB SENSE"
		}
	}
	gpio_outputs {
		usb_dp_pu: usb_dp_pu {
			gpios = <&gpioa 9 GPIO_ACTIVE_HIGH>;
			label = "USB RENUMERATION"
		}
	}
};

&clk_lsi {
	status = "okay";
};

&clk_hse {
	hse-bypass;
	clock-frequency = <DT_FREQ_M(8)>; /* 8MHz clock */
	status = "okay";
};

&pll {
	prediv = <1>;
	mul = <9>;
	clocks = <&clk_hse>;
	status = "okay";
};

&rcc {
	clocks = <&pll>;
	clock-frequency = <DT_FREQ_M(72)>;
	ahb-prescaler = <1>;
	apb1-prescaler = <2>;
	apb2-prescaler = <1>;
};

// OK Free pins: pa14 (SWD SWCLK), pa15 (I2C SCL) (pulled up)
&usart2 {
	pinctrl-0 = <&usart2_tx_pa14 &usart2_rx_pa15>;
	pinctrl-names = "default";
	current-speed = <115200>;
	status = "okay";
};

// OK
&i2c1 {
	pinctrl-0 = <&i2c1_scl_pa15 &i2c1_sda_pb7>;
	pinctrl-names = "default";
	status = "okay";
	clock-frequency = <I2C_BITRATE_FAST>;
};

// OK (Add renumn pin)
zephyr_udc0: &usb {
	pinctrl-0 = <&usb_dm_pa11 &usb_dp_pa12>;
	pinctrl-names = "default";
	status = "okay";
};

&rtc {
	clocks = <&rcc STM32_CLOCK_BUS_APB1 0x10000000>,
		 <&rcc STM32_SRC_LSI RTC_SEL(2)>;
	status = "okay";

	backup_regs {
		status = "okay";
	};
};

// OK
&can1 {
	pinctrl-0 = <&can_rx_pb8 &can_tx_pb9>;
	pinctrl-names = "default";
	status = "okay";
	bus-speed = <125000>;
};

&flash0 {
	partitions {
		compatible = "fixed-partitions";
		#address-cells = <1>;
		#size-cells = <1>;

		/* Set 6Kb of storage at the end of the 256Kb of flash */
		storage_partition: partition@3e800 {
			label = "storage";
			reg = <0x0003e800 DT_SIZE_K(6)>;
		};
	};
};

&iwdg {
	status = "okay";
};

&timers1 {
	st,prescaler = <10000>;
	status = "okay";
	pwm1: pwm {
		status = "okay";
		pinctrl-0 = <&tim1_ch1_pa8>;
		pinctrl-names = "default";
	};
};


// PA1: Gvirtual
// PA2: U_DIV
&adc1 {
	pinctrl-0 = <&adc1_in1_pa1 &adc1_in3_pa2>;
	pinctrl-names = "default";
	st,adc-clock-source = <SYNC>;
	st,adc-prescaler = <2>;
	status = "okay";
};

// PA5: V_DIV
// PA6: W_DIV
// PB2: W_CURRENT
&adc2 {
	pinctrl-0 = <&adc2_in2_pa5 &adc2_in3_pa6 adc2_in12_pb2>;
	pinctrl-names = "default";
	st,adc-clock-source = <SYNC>;
	st,adc-prescaler = <2>;
	status = "okay";
};

// PB13: U_CURRENT
&adc3 {
	pinctrl-0 = <&adc3_in5_pb13>;
	pinctrl-names = "default";
	st,adc-clock-source = <SYNC>;
	st,adc-prescaler = <2>;
	status = "okay";
};

// PB12: V_CURRENT
// PB14: MEAS_TEMP
// PB15: MEAS_BAT
&adc4 {
	pinctrl-0 = <&adc4_in3_pb12 &adc4_in4_pb14 &adc4_in5_pb15>;
	pinctrl-names = "default";
	st,adc-clock-source = <SYNC>;
	st,adc-prescaler = <2>;
	status = "okay";
};

&die_temp {
	status = "okay";
};

&dma1 {
	status = "okay";
};

&vref {
	status = "okay";
};

&vbat {
	status = "okay";
};
